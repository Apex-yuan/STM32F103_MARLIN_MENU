# Keil uVision project STM32F103.uvprojx, settings and files
target Debug (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32c8t6_template +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\BSP\systick;..\BSP\usart;..\BSP\tfs-m64;..\BSP;..\BSP\WS281x;..\BSP\HC-SR04;..\BSP\lcd12864;..\BSP\tim;..\BSP\key;..\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group StdLib
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group BSP
    ../BSP/: bsp.c
    ../BSP/systick/: bsp_systick.c
    ../BSP/usart/: bsp_usart.c
    ../BSP/key/: bsp_key.c
    ../BSP/tim/: bsp_tim.c
    ../BSP/lcd12864/: bsp_lcd12864.c
  group APP
    ../APP/: menu.c
  group User
    ../User/: stm32f10x_it.c main.c
  group Doc
    ../Doc/: log.md
